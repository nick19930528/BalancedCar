# Keil uVision project Program_STM32.uvproj, settings and files
target STM32F407VGT (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F407VGT
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../Libraries/CMSIS/startup/: startup_stm32f4xx.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_flash.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_tim.c
  group Program
    ../Program/: experiment_stm32f4.c experiment_stm32f4_it.c
  group Library
    ../Program/: stm32f4_system.c stm32f4_delay.c stm32f4_usart.c stm32f4_i2c.c module_rs232.c module_sensor.c module_mpu6050.c
